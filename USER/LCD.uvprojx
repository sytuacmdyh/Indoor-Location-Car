# Keil uVision project LCD.uvprojx, settings and files
target SmartCar (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartCar +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\USART3;..\HARDWARE\MOTOR;..\HARDWARE\USART2;..\HARDWARE\W25QXX;..\HARDWARE\VS10XX;..\HARDWARE\SPI;..\HARDWARE\SDIO;..\SOFTWARE\MALLOC;..\HARDWARE\SD;..\SOFTWARE\MUSIC;..\HARDWARE\BEEP;..\HARDWARE\DISTENCE;..\HARDWARE\SERVO;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/VS10XX/: vs10xx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DISTENCE/: sr04.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group SOFTWARE
    ../SOFTWARE/MALLOC/: malloc.c
    ../SOFTWARE/MUSIC/: mp3player.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group SD_CARD
    ../HARDWARE/SD/: diskio.c exfuns.c fattester.c ff.c fontupd.c mycc936.c text.c sdio_sdcard.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_sdio.c stm32f10x_spi.c
  group README
    ../: README.md
